# Keil uVision project train_controller_board.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: train_controller_board
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: AIR001_DEV
  c include: .\User\inc;.\Libraries\AIR001xx_HAL_Driver\Inc;.\Libraries\AIR001xx_HAL_Driver\Inc\Legacy;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\AIR001xx\Include;D:\Keil_v5\ARM\Pack\Keil\AIR001_DFP\1.1.0\Device\Include;D:\Keil_v5\ARM\Pack\ARM\CMSIS\5.9.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group HAL
    ./Libraries/AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_cortex.c air001xx_hal_flash.c air001xx_hal_gpio.c air001xx_hal_rcc.c air001xx_hal_pwr.c air001xx_hal_dma.c air001xx_hal_uart.c
  group User
    ./User/src/: main.c air001xx_it.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.0.1
